# Keil uVision project Hotels_LockV1.uvproj, settings and files
target Hotels_Lock (MCS-51)
  device: P89LPC931 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(12000000) MODP2
  output: Hotels_LockV1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User_Include;.\User_Source;..\Hotels_LockV1_0
  group AMS
    ./AMS/: START900.A51
  group Source
    ./User_Source/: Hotels_V1Main_Task.C Hotels_Group_Fun.c HI2C_C51.c Interrupt.C Serial.c
  group Include
    ./User_Include/: Group_Fun.h Group_Pin.h HI2C_C51.h FM1702.h Serial.h
